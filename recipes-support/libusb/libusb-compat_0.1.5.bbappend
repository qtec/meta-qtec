FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI+="file://crosscompile-config.patch"
