DEPENDS += "numactl xz"
FILES_${PN} += "${prefix}/libexec/perf-core"
