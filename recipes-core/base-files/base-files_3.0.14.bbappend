FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

dirs755_append = " /media/rw /boot/efi"
