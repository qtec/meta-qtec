PNBLACKLIST[openjdk-7-jre] = "SIGSEGV on libjvm.so+0x4ca0d0 JNI_GetCreatedJavaVMs+0x16f20"
