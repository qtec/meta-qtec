FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://getintegerv.patch"
SRC_URI += "file://fixeglbuild.patch"
