FILESEXTRAPATHS_prepend := "${THISDIR}/mesa-demos:"
SRC_URI_append_qt5022-fglrx = "file://disable_egl.patch"
