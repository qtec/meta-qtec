PACKAGECONFIG = "udev dri dri2 xinerama"
