QTDEMOS_remove += "qmmp"
