do_install_append(){
	rm -r ${D}/${bindir}
}
